# Keil uVision project template_f4.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template_f4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: .\driver\STM32F4xx_StdPeriph_Driver\inc;.\start;.\user;.\common;.\driver\usart;.\driver\spi;.\interface\st7789v2;.\interface\zxc_st7789;.\driver\timer;.\freertos;.\freertos\ARM_CM4F;.\freertos\include;.\lvgl;.\lvgl\porting;.\driver\dma;.\driver\i2c;.\interface\zxc_htu21d;.\interface\max30102;.\interface\max30102\algorithm;.\driver\adc;.\resource;.\common\DspFilters\include;.\network\AI\Inc;.\network\X-CUBE-AI\App
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./user/: main.h main.cpp zxc_interrupt.cpp zxc_rtos.cpp zxc_lvgl.cpp zxc_tflm.cpp
    ./resource/: zxc_model.cpp
  group start
    ./start/: startup_stm32f411xe.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c
  group driver
    ./driver/spi/: zxc_spi.cpp
    ./driver/timer/: zxc_timer3.cpp
    ./driver/usart/: usart.c
    ./driver/dma/: zxc_dma.cpp zxc_dma_adc.cpp
    ./driver/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_i2c.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_adc.c
    ./driver/i2c/: zxc_i2c.cpp
    ./common/: zxc_sys_tick_clock.c
    ./driver/adc/: zxc_adc.cpp zxc_adc_touch.cpp
  group common
    ./common/: zxc_sys_clock_config.c zxc_debug.c zxc_utils.cpp
  group interface
    ./interface/zxc_st7789/: zxc_st7789.cpp
    ./interface/zxc_htu21d/: zxc_htu21d.cpp
    ./interface/max30102/: zxc_max30102.cpp
    ./interface/max30102/algorithm/: algorithm.cpp
  group freertos
    ./freertos/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./freertos/ARM_CM4F/: port.c
  group lvgl
    ./lvgl/src/: lv_init.c
    ./lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ./lvgl/src/display/: lv_display.c
    ./lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ./lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ./lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ./lvgl/src/draw/sdl/: lv_draw_sdl.c
    ./lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ./lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ./lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ./lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ./lvgl/src/drivers/display/drm/: lv_linux_drm.c
    ./lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ./lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ./lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ./lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ./lvgl/src/drivers/display/st7735/: lv_st7735.c
    ./lvgl/src/drivers/display/st7789/: lv_st7789.c
    ./lvgl/src/drivers/display/st7796/: lv_st7796.c
    ./lvgl/src/drivers/evdev/: lv_evdev.c
    ./lvgl/src/drivers/glfw/: lv_glfw_mouse.c lv_glfw_mouse_private.c lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c
    ./lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ./lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ./lvgl/src/drivers/qnx/: lv_qnx.c
    ./lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ./lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ./lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ./lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
    ./lvgl/src/layouts/flex/: lv_flex.c
    ./lvgl/src/layouts/grid/: lv_grid.c
    ./lvgl/src/layouts/: lv_layout.c
    ./lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ./lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ./lvgl/src/libs/bmp/: lv_bmp.c
    ./lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ./lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ./lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ./lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ./lvgl/src/libs/libpng/: lv_libpng.c
    ./lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ./lvgl/src/libs/lz4/: lz4.c
    ./lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./lvgl/src/libs/rle/: lv_rle.c
    ./lvgl/src/libs/rlottie/: lv_rlottie.c
    ./lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ./lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ./lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
    ./lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ./lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
    ./lvgl/src/others/file_explorer/: lv_file_explorer.c
    ./lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./lvgl/src/others/gridnav/: lv_gridnav.c
    ./lvgl/src/others/ime/: lv_ime_pinyin.c
    ./lvgl/src/others/imgfont/: lv_imgfont.c
    ./lvgl/src/others/monkey/: lv_monkey.c
    ./lvgl/src/others/observer/: lv_observer.c
    ./lvgl/src/others/snapshot/: lv_snapshot.c
    ./lvgl/src/others/sysmon/: lv_sysmon.c
    ./lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ./lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ./lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ./lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ./lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ./lvgl/src/stdlib/: lv_mem.c
    ./lvgl/src/themes/default/: lv_theme_default.c
    ./lvgl/src/themes/mono/: lv_theme_mono.c
    ./lvgl/src/themes/simple/: lv_theme_simple.c
    ./lvgl/src/themes/: lv_theme.c
    ./lvgl/src/tick/: lv_tick.c
    ./lvgl/src/widgets/animimage/: lv_animimage.c
    ./lvgl/src/widgets/arc/: lv_arc.c
    ./lvgl/src/widgets/bar/: lv_bar.c
    ./lvgl/src/widgets/button/: lv_button.c
    ./lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ./lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./lvgl/src/widgets/canvas/: lv_canvas.c
    ./lvgl/src/widgets/chart/: lv_chart.c
    ./lvgl/src/widgets/checkbox/: lv_checkbox.c
    ./lvgl/src/widgets/dropdown/: lv_dropdown.c
    ./lvgl/src/widgets/image/: lv_image.c
    ./lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ./lvgl/src/widgets/keyboard/: lv_keyboard.c
    ./lvgl/src/widgets/label/: lv_label.c
    ./lvgl/src/widgets/led/: lv_led.c
    ./lvgl/src/widgets/line/: lv_line.c
    ./lvgl/src/widgets/list/: lv_list.c
    ./lvgl/src/widgets/lottie/: lv_lottie.c
    ./lvgl/src/widgets/menu/: lv_menu.c
    ./lvgl/src/widgets/msgbox/: lv_msgbox.c
    ./lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ./lvgl/src/widgets/property/: lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_style_properties.c lv_textarea_properties.c
    ./lvgl/src/widgets/roller/: lv_roller.c
    ./lvgl/src/widgets/scale/: lv_scale.c
    ./lvgl/src/widgets/slider/: lv_slider.c
    ./lvgl/src/widgets/span/: lv_span.c
    ./lvgl/src/widgets/spinbox/: lv_spinbox.c
    ./lvgl/src/widgets/spinner/: lv_spinner.c
    ./lvgl/src/widgets/switch/: lv_switch.c
    ./lvgl/src/widgets/table/: lv_table.c
    ./lvgl/src/widgets/tabview/: lv_tabview.c
    ./lvgl/src/widgets/textarea/: lv_textarea.c
    ./lvgl/src/widgets/tileview/: lv_tileview.c
    ./lvgl/src/widgets/win/: lv_win.c
    ./lvgl/porting/: lv_port_disp.cpp
  group resoucrce
    ./resource/: zxc_o2.c hello_world_int8_model_data.cc
  group network
    ./network/AI/Lib/: NetworkRuntime900_CM4_Keil.lib
    ./network/X-CUBE-AI/App/: test.c test_data.c test_data_params.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
